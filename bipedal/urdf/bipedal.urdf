Commit message: Clean

File: bipedal/urdf/bipedal.urdf (robot description, URDF)
Before this commit: robot quadrupedal_robot, 13 links, 12 joints
Links:
- link l_tipLink: mass 0.093204 -> 0.139622
- link r_tipLink: mass 0.093204 -> 0.139622
